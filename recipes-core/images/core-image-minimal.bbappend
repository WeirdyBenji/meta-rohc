IMAGE_INSTALL:append = " librohc"
